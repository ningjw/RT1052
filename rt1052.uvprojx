# Keil uVision project rt1052.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1052
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,USE_RAM_VECTOR_TABLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: .\board;.\User\inc;.\xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1052CVL5B\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --keep=*(.boot_hdr.ivt)
--keep=*(.boot_hdr.boot_data)
--keep=*(.boot_hdr.dcd_data)
--keep=*(.boot_hdr.conf)
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Driver
    ./User/src/: main.c interrupt.c lpuart1.c
  group Board
    ./board/: clock_config.c peripherals.c pin_mux.c
  group xip
    ./xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Coroutines 10.2.0, RTOS:Event Groups 10.2.0, RTOS:Heap 10.2.0, RTOS:Message Buffer 10.2.0, RTOS:Stream Buffer 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.3.0, CMSIS:RTOS2:FreeRTOS 10.2.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.1.0, Device:SDK Drivers:dmamux 2.0.2, Device:SDK Drivers:edma 2.1.8, Device:SDK Drivers:gpt 2.0.0, Device:SDK Drivers:iomuxc 2.0.0, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.2.7, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:pit 2.0.2, Device:SDK Drivers:qtmr 2.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:notifier 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:SDK Utilities:shell 1.0.0, Device:Startup:MIMXRT1052_startup 1.0.0
