# Keil uVision project RT1052.uvprojx, settings and files
target ram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1052 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MIMXRT1052CVL5B
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\CMSIS;..\FSLLibrary;..\User;..\utilities
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\SCRIPT\rt1052_ram_scf.scf
  group CMSIS
    ../User/: system_MIMXRT1052.c
    ../CMSIS/: startup_MIMXRT1052.s
  group User
    ../User/: main.c device_init.c lpuart.c usb_app.c usb_util.c usb_ehci.c usb_ufi.c
    ../: readme.txt
  group utilities
    ../utilities/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_shell.c fsl_str.c fsl_log.c fsl_io.c
  group FSLLibrary
    ../FSLLibrary/: fsl_common.c fsl_clock.c fsl_gpio.c fsl_lpuart.c
  group fatfs
    ../fatfs/src/: ff.c diskio.c
target sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: RT1052 +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B
  c misc: as above
  c include: ..\CORE;..\FSLLibrary;..\SYSTEM;..\User;..\utilities
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\SCRIPT\rt1052_sdram_scf.scf
target flexspi_debug_release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: RT1052 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,USB_STACK_BM,HOST_ECHO
  c misc: as above
  c include: ..\CMSIS;..\FSLLibrary;..\User;..\utilities;..\usb;..\usb\osa;..\usb\include;..\usb\host;..\usb\host\class;..\usb\phy;..\fatfs\src\option;..\fatfs\src
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\SCRIPT\rt1052_flexspi_scf.scf
